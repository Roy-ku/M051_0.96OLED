# Keil uVision project I2C_SSD1306.uvprojx, settings and files
target SSD1306 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M058LDN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: SSD1306 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\CORE\Device\Nuvoton\M051Series\Include;..\CORE\CMSIS\Include;..\CORE\StdDriver\inc;..\External;..\HARDWARE;..\SYSTEM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CORE
    ../CORE/StdDriver/src/: adc.c clk.c gpio.c i2c.c pwm.c sys.c timer.c uart.c spi.c acmp.c ebi.c fmc.c wdt.c wwdt.c
  group SYSTEM
    ../SYSTEM/: User_Delay.c SW_I2C.c Oled_bmp.c
  group HARDWARE
    ../HARDWARE/: OLED_SSD1306_Driver.c OLED_SSD1306_Config.c
  group USER
    ../USER/: main.c
  group Readme
    ../: README.md .gitignore
software components: CMSIS:CORE 5.1.2, Device:Startup 0.00.001
